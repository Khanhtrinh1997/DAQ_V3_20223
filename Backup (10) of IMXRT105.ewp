# IAR project Backup (10) of IMXRT105.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1052DVL6B; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; SKIP_SYSCLK_INIT; GPL_LICENSE_TERMS_ACCEPTED; _DLIB_FILE_DESCRIPTOR; USE_MIMXRT1050_EVKB; __ICCARM__; __IAR_SYSTEMS_ICC__=9; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_DCD_ENABLE=1; XIP_BOOT_HEADER_ENABLE=0
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; source; CMSIS; component/lists; component/serial_manager; component/uart; device; drivers; freertos/freertos_kernel/include; freertos/freertos_kernel/portable/IAR/ARM_CM4F; utilities; xip; tcp_stack\common; tcp_stack\cyclone_crypto; tcp_stack\cyclone_tcp; tcp_stack\tcp_config; tcp_stack; tcp_stack\cyclone_tcp\core; tcp_stack\cyclone_tcp\dhcp; tcp_stack\cyclone_tcp\dns; tcp_stack\cyclone_tcp\drivers\mac; tcp_stack\cyclone_tcp\drivers\phy; tcp_stack\cyclone_tcp\ftp; tcp_stack\cyclone_tcp\http; tcp_stack\cyclone_tcp\ipv4; tcp_stack\cyclone_tcp\ipv6; tcp_stack\cyclone_tcp\mdns; tcp_stack\cyclone_tcp\mibs; tcp_stack\cyclone_tcp\netbios; tcp_stack\cyclone_tcp\snmp; tcp_stack\cyclone_crypto\cipher; tcp_stack\cyclone_crypto\cipher_mode; tcp_stack\cyclone_crypto\core; tcp_stack\cyclone_crypto\encoding; tcp_stack\cyclone_crypto\hash; tcp_stack\cyclone_crypto\mac; tcp_stack\cyclone_tcp\drivers; tcp_stack\cyclone_tcp\dns; tcp_stack\cyclone_tcp\web_socket; tcp_stack\cyclone_tcp\igmp; tcp_stack\cyclone_crypto\hardware; tcp_stack\cyclone_crypto\hardware\mimxrt1050
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: source
  OBJCOPY.OOCOutputFile: DAQV3_IMXRT105.hex
  ILINK.IlinkOutputFile: freertos_hello.out
  ILINK.IlinkIcfFile: MIMXRT1052\iar\MIMXRT1052xxxxx_flexspi_nor_sdram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1052DVL6B; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: board; source; CMSIS; component/lists; component/serial_manager; component/uart; device; drivers; freertos/freertos_kernel/include; freertos/freertos_kernel/portable/IAR/ARM_CM4F; utilities; xip
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1052/iar/MIMXRT1052xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1052DVL6B; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1052/iar/MIMXRT1052xxxxx_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1052DVL6B; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1052/iar/MIMXRT1052xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1052DVL6B; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1052/iar/MIMXRT1052xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration sdram_release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1052DVL6B; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1052/iar/MIMXRT1052xxxxx_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group board
    board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/serial_manager
    component/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpspi.c fsl_lpspi.h fsl_lpuart.c fsl_lpuart.h fsl_semc.c fsl_semc.h fsl_trng.c fsl_trng.h fsl_wdog.c fsl_wdog.h
  group evkbimxrt1050
    evkbimxrt1050/: evkbimxrt1050.mac evkbimxrt1050_sdram_init.mac
  group freertos/freertos_kernel
    freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group freertos/freertos_kernel/portable
    freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group MIMXRT1052/iar
    MIMXRT1052/iar/: MIMXRT1052xxxxx_flexspi_nor_sdram.icf
  group source
    source/: crc32_cal.c crc32_cal.h daq_v3_agisson.c daq_v3_agisson.h daq_v3_agisson_task.c daq_v3_agisson_task.h daq_v3_config.c daq_v3_config.h daq_v3_control_task.c daq_v3_control_task.h daq_v3_dpc_driver.c daq_v3_dpc_driver.h daq_v3_dpc_task.c daq_v3_dpc_task.h daq_v3_driver_function.c daq_v3_driver_function.h daq_v3_emer_driver.c daq_v3_emer_driver.h daq_v3_emerson_m221_task.c daq_v3_emerson_m221_task.h daq_v3_emerson_m500d_task.c daq_v3_emerson_m500d_task.h daq_v3_flash_spi.c daq_v3_flash_spi.h daq_v3_ftp.c daq_v3_ftp.h daq_v3_modbus_rtu.c daq_v3_modbus_rtu.h daq_v3_private_mib_impl.c daq_v3_private_mib_impl.h daq_v3_private_mib_module.c daq_v3_private_mib_module.h daq_v3_rs485.c daq_v3_rs485.h daq_v3_uart.c daq_v3_uart.h daq_v3_variables.c daq_v3_variables.h daq_v3_zte_driver.c daq_v3_zte_driver.h daq_v3_zte_hislog.c daq_v3_zte_hislog.h daq_v3_zte_task.c daq_v3_zte_task.h FreeRTOSConfig.h ftp_client_test.c ftp_client_test.h header_files.h http_handler.c http_handler.h imx_lpuart.c imx_lpuart.h main.c res.c semc_init.c snmp_handler.c snmp_handler.h
  group startup
    startup/: startup_MIMXRT1052.s
  group tcp_stack/common
    tcp_stack/common/: compiler_port.h cpu_endian.c cpu_endian.h date_time.c date_time.h debug.c debug.h error.h fs_port.h os_port.h os_port_freertos.c os_port_freertos.h path.c path.h resource_manager.c resource_manager.h str.c str.h
  group tcp_stack/cyclone_crypto
    tcp_stack/cyclone_crypto/cipher/: aes.c aes.h des.c des.h
    tcp_stack/cyclone_crypto/encoding/: asn1.c asn1.h oid.c oid.h
    tcp_stack/cyclone_crypto/cipher_mode/: cbc.c cbc.h cfb.c cfb.h
    tcp_stack/cyclone_crypto/core/: crypto.h
    tcp_stack/cyclone_crypto/mac/: hmac.c hmac.h
    tcp_stack/cyclone_crypto/hash/: md5.c md5.h sha1.c sha1.h
  group tcp_stack/cyclone_crypto/hardware/mimxrt1050
    tcp_stack/cyclone_crypto/hardware/mimxrt1050/: mimxrt1050_crypto.c mimxrt1050_crypto.h mimxrt1050_crypto_trng.c mimxrt1050_crypto_trng.h
  group tcp_stack/cyclone_crypto/rng
    tcp_stack/cyclone_crypto/rng/: trng.h yarrow.c yarrow.h
  group tcp_stack/cyclone_tcp/core
    tcp_stack/cyclone_tcp/core/: bsd_socket.c bsd_socket.h bsd_socket_misc.c bsd_socket_misc.h ethernet.c ethernet.h ethernet_misc.c ethernet_misc.h ip.c ip.h net.c net.h net_legacy.h net_mem.c net_mem.h net_misc.c net_misc.h nic.c nic.h ping.c ping.h raw_socket.c raw_socket.h socket.c socket.h socket_misc.c socket_misc.h tcp.c tcp.h tcp_fsm.c tcp_fsm.h tcp_misc.c tcp_misc.h tcp_timer.c tcp_timer.h udp.c udp.h
  group tcp_stack/cyclone_tcp/dhcp
    tcp_stack/cyclone_tcp/dhcp/: dhcp_client.c dhcp_client.h dhcp_common.c dhcp_common.h dhcp_debug.c dhcp_debug.h dhcp_server.h
  group tcp_stack/cyclone_tcp/dns
    tcp_stack/cyclone_tcp/dns/: dns_cache.c dns_cache.h dns_client.c dns_client.h dns_common.c dns_common.h dns_debug.c dns_debug.h
  group tcp_stack/cyclone_tcp/drivers
    tcp_stack/cyclone_tcp/drivers/phy/: dp83825_driver.c dp83825_driver.h lan8720_driver.c lan8720_driver.h
    tcp_stack/cyclone_tcp/drivers/mac/: mimxrt1050_eth_driver.c mimxrt1050_eth_driver.h
  group tcp_stack/cyclone_tcp/ftp
    tcp_stack/cyclone_tcp/ftp/: ftp_client.c ftp_client.h ftp_client_misc.c ftp_client_misc.h ftp_client_transport.c ftp_client_transport.h
  group tcp_stack/cyclone_tcp/http
    tcp_stack/cyclone_tcp/http/: http_server.c http_server.h http_server_auth.c http_server_auth.h http_server_misc.c http_server_misc.h mime.c mime.h ssi.c ssi.h
  group tcp_stack/cyclone_tcp/igmp
    tcp_stack/cyclone_tcp/igmp/: igmp_common.c igmp_common.h igmp_host.c igmp_host.h igmp_host_misc.c igmp_host_misc.h igmp_router.c igmp_router.h igmp_router_misc.c igmp_router_misc.h igmp_snooping.c igmp_snooping.h igmp_snooping_misc.c igmp_snooping_misc.h
  group tcp_stack/cyclone_tcp/ipv4
    tcp_stack/cyclone_tcp/ipv4/: arp.c arp.h auto_ip.c auto_ip.h auto_ip_misc.c auto_ip_misc.h icmp.c icmp.h ipv4.c ipv4.h ipv4_frag.c ipv4_frag.h ipv4_misc.c ipv4_misc.h ipv4_routing.h
  group tcp_stack/cyclone_tcp/ipv6
    tcp_stack/cyclone_tcp/ipv6/: icmpv6.c icmpv6.h ipv6.c ipv6.h ipv6_frag.c ipv6_frag.h ipv6_misc.c ipv6_misc.h ipv6_pmtu.c ipv6_pmtu.h ipv6_routing.h mld.c mld.h ndp.c ndp.h ndp_cache.c ndp_cache.h ndp_misc.c ndp_misc.h ndp_router_adv.h slaac.c slaac.h
  group tcp_stack/cyclone_tcp/llmnr
    tcp_stack/cyclone_tcp/llmnr/: llmnr_client.c llmnr_client.h llmnr_common.c llmnr_common.h llmnr_responder.c llmnr_responder.h
  group tcp_stack/cyclone_tcp/mdns
    tcp_stack/cyclone_tcp/mdns/: mdns_client.c mdns_client.h mdns_common.c mdns_common.h mdns_responder.c mdns_responder.h
  group tcp_stack/cyclone_tcp/mibs
    tcp_stack/cyclone_tcp/mibs/: if_mib_impl.c if_mib_impl.h if_mib_module.c if_mib_module.h ip_mib_impl.c ip_mib_impl.h ip_mib_module.c ip_mib_module.h lldp_mib_impl.c lldp_mib_impl.h lldp_mib_impl_config.c lldp_mib_impl_config.h lldp_mib_impl_local.c lldp_mib_impl_local.h lldp_mib_impl_remote.c lldp_mib_impl_remote.h lldp_mib_impl_stats.c lldp_mib_impl_stats.h lldp_mib_module.c lldp_mib_module.h mib2_impl.c mib2_impl.h mib2_impl_if.c mib2_impl_if.h mib2_impl_ip.c mib2_impl_ip.h mib2_impl_sys.c mib2_impl_sys.h mib2_impl_tcp.c mib2_impl_tcp.h mib2_impl_udp.c mib2_impl_udp.h mib2_module.c mib2_module.h mib_common.c mib_common.h snmp_community_mib_impl.c snmp_community_mib_impl.h snmp_community_mib_module.c snmp_community_mib_module.h snmp_framework_mib_impl.c snmp_framework_mib_impl.h snmp_framework_mib_module.c snmp_framework_mib_module.h snmp_mib_impl.c snmp_mib_impl.h snmp_mib_module.c snmp_mib_module.h snmp_mpd_mib_impl.c snmp_mpd_mib_impl.h snmp_mpd_mib_module.c snmp_mpd_mib_module.h snmp_usm_mib_impl.c snmp_usm_mib_impl.h snmp_usm_mib_module.c snmp_usm_mib_module.h snmp_vacm_mib_impl.c snmp_vacm_mib_impl.h snmp_vacm_mib_module.c snmp_vacm_mib_module.h tcp_mib_impl.c tcp_mib_impl.h tcp_mib_module.c tcp_mib_module.h udp_mib_impl.c udp_mib_impl.h udp_mib_module.c udp_mib_module.h
  group tcp_stack/cyclone_tcp/netbios
    tcp_stack/cyclone_tcp/netbios/: nbns_client.c nbns_client.h nbns_common.c nbns_common.h nbns_responder.c nbns_responder.h
  group tcp_stack/cyclone_tcp/snmp
    tcp_stack/cyclone_tcp/snmp/: snmp_agent.c snmp_agent.h snmp_agent_dispatch.c snmp_agent_dispatch.h snmp_agent_inform.c snmp_agent_inform.h snmp_agent_message.c snmp_agent_message.h snmp_agent_misc.c snmp_agent_misc.h snmp_agent_object.c snmp_agent_object.h snmp_agent_pdu.c snmp_agent_pdu.h snmp_agent_trap.c snmp_agent_trap.h snmp_agent_usm.c snmp_agent_usm.h snmp_agent_vacm.c snmp_agent_vacm.h snmp_common.h
  group tcp_stack/cyclone_tcp/web_socket
    tcp_stack/cyclone_tcp/web_socket/: web_socket.c web_socket.h web_socket_auth.c web_socket_auth.h web_socket_frame.c web_socket_frame.h web_socket_misc.c web_socket_misc.h web_socket_transport.c web_socket_transport.h
  group tcp_stack/tcp_config
    tcp_stack/tcp_config/: crypto_config.h fs_port_config.h net_config.h os_port_config.h
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
  group xip
    xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
